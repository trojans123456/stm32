# Keil uVision project alientek.uvproj, settings and files
target alientek (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: alientek +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\arch\M4;..\board\alientek;..\common;..\Libraries\stm32f4\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group arch
    ../arch/M4/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group board
    ../board/alientek/: board.c usart.c
  group Libraries
    ../Libraries/stm32f4/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group common
    ../common/: device.c fifo.c
  group app
    ../app/: main.c
